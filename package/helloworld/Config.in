## package/helloworld/Config.in
```kconfig
config BR2_HELLO_WORLD
	bool "helloworld"
	help
		This is will print hello world when executed.
```
